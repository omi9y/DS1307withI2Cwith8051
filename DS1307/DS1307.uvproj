# Keil uVision project DS1307.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: DS1307 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: I2C.h I2C.c DS1307.h DS1307.c Includes.h Main.c
